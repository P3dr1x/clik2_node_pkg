Commit message: references prep

File: model/t960a.urdf (robot description, URDF)
Before this commit: robot t960a, 15 links, 14 joints
Joints:
- joint drone_arm: origin xyz=0.4265 0 -0.063 rpy=3.14 0 0 -> xyz=0.4265 0 -0.0845 rpy=3.14 0 0
